# Keil uVision project SSE310_NS.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: SSE-310-MPS3_AN555 ARM
  pack: ARM.V2M_MPS3_SSE_310_BSP.1.4.0
  cpu: IRAM(0x31000000,0x00020000) IRAM2(0x00000000,0x00008000) IROM(0x11000000,0x00200000) XRAM(0x01000000,0x00200000) XRAM2(0x20000000,0x00002000) XRAM3(0x20002000,0x00002000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: SSE310_NS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=2
  memory RVCT4: ROM 0x11000000 size 0x200000
  memory RVCT5: ROM 0x1020000 size 0x200000
  memory RVCT7: RAM 0x20000000 size 0x2000
  memory RVCT8: RAM 0x20002000 size 0x2000
  memory RVCT9: RAM 0x31000000 size 0x20000
  memory RVCT10: RAM 0x21040000 size 0x4000
  scatter file: .\RTE\Device\SSE-310-MPS3_AN555\linker_SSE310MPS3_non_secure.sct
  group Source Group 1
    ./: main_ns.c
  group CMSE Library
    ../SSE310_S/: Secure_Functions.h
    ../SSE310_S/Objects/: SSE310_S_CMSE_Lib.o
software components: CMSIS Driver:USART 1.1.0, CMSIS:CORE 6.0.0, Device:Definition 2.0.0, Device:Native Driver:UART 1.1.0, Device:Startup 2.0.0, Compiler:I/O:STDOUT 1.2.0
